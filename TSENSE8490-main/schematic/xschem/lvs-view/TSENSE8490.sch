v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {Small} 2620 -1250 0 0 0.4 0.4 {}
T {Medium} 2790 -1250 0 0 0.4 0.4 {}
T {Large} 2980 -1250 0 0 0.4 0.4 {}
N 3430 -1060 3440 -1060 {lab=Q0}
N 3430 -1000 3440 -1000 {lab=Q3}
N 3430 -1040 3520 -1040 {lab=Q1}
N 3430 -1020 3520 -1020 {lab=Q2}
N 170 -490 270 -490 {lab=ENP}
N 170 -530 170 -490 {lab=ENP}
N 160 -490 170 -490 {lab=ENP}
N 170 -610 170 -590 {lab=VDD}
N 170 -390 170 -370 {lab=VSS}
N 170 -470 170 -450 {lab=ENP}
N 160 -470 170 -470 {lab=ENP}
N 160 -490 160 -470 {lab=ENP}
N 130 -490 160 -490 {lab=ENP}
N 110 -510 130 -510 {lab=ENP}
N 130 -510 130 -490 {lab=ENP}
N 100 -490 130 -490 {lab=ENP}
N 510 -490 610 -490 {lab=ENN}
N 510 -530 510 -490 {lab=ENN}
N 500 -490 510 -490 {lab=ENN}
N 510 -610 510 -590 {lab=VDD}
N 510 -390 510 -370 {lab=VSS}
N 510 -470 510 -450 {lab=ENN}
N 500 -470 510 -470 {lab=ENN}
N 500 -490 500 -470 {lab=ENN}
N 470 -490 500 -490 {lab=ENN}
N 450 -510 470 -510 {lab=ENN}
N 470 -510 470 -490 {lab=ENN}
N 440 -490 470 -490 {lab=ENN}
N 860 -490 960 -490 {lab=RO_RAW}
N 860 -530 860 -490 {lab=RO_RAW}
N 850 -490 860 -490 {lab=RO_RAW}
N 860 -610 860 -590 {lab=VDD}
N 860 -390 860 -370 {lab=VSS}
N 860 -470 860 -450 {lab=RO_RAW}
N 850 -470 860 -470 {lab=RO_RAW}
N 850 -490 850 -470 {lab=RO_RAW}
N 820 -490 850 -490 {lab=RO_RAW}
N 800 -510 820 -510 {lab=RO_RAW}
N 820 -510 820 -490 {lab=RO_RAW}
N 790 -490 820 -490 {lab=RO_RAW}
N 1210 -490 1310 -490 {lab=RO_BUF}
N 1210 -530 1210 -490 {lab=RO_BUF}
N 1200 -490 1210 -490 {lab=RO_BUF}
N 1210 -610 1210 -590 {lab=VDD}
N 1210 -390 1210 -370 {lab=VSS}
N 1210 -470 1210 -450 {lab=RO_BUF}
N 1200 -470 1210 -470 {lab=RO_BUF}
N 1200 -490 1200 -470 {lab=RO_BUF}
N 1170 -490 1200 -490 {lab=RO_BUF}
N 1150 -510 1170 -510 {lab=RO_BUF}
N 1170 -510 1170 -490 {lab=RO_BUF}
N 1140 -490 1170 -490 {lab=RO_BUF}
N 170 -160 270 -160 {lab=Q0}
N 170 -200 170 -160 {lab=Q0}
N 160 -160 170 -160 {lab=Q0}
N 170 -280 170 -260 {lab=VDD}
N 170 -60 170 -40 {lab=VSS}
N 170 -140 170 -120 {lab=Q0}
N 160 -140 170 -140 {lab=Q0}
N 160 -160 160 -140 {lab=Q0}
N 130 -160 160 -160 {lab=Q0}
N 110 -180 130 -180 {lab=Q0}
N 130 -180 130 -160 {lab=Q0}
N 100 -160 130 -160 {lab=Q0}
N 510 -160 610 -160 {lab=Q1}
N 510 -200 510 -160 {lab=Q1}
N 500 -160 510 -160 {lab=Q1}
N 510 -280 510 -260 {lab=VDD}
N 510 -60 510 -40 {lab=VSS}
N 510 -140 510 -120 {lab=Q1}
N 500 -140 510 -140 {lab=Q1}
N 500 -160 500 -140 {lab=Q1}
N 470 -160 500 -160 {lab=Q1}
N 450 -180 470 -180 {lab=Q1}
N 470 -180 470 -160 {lab=Q1}
N 440 -160 470 -160 {lab=Q1}
N 860 -160 960 -160 {lab=Q2}
N 860 -200 860 -160 {lab=Q2}
N 850 -160 860 -160 {lab=Q2}
N 860 -280 860 -260 {lab=VDD}
N 860 -60 860 -40 {lab=VSS}
N 860 -140 860 -120 {lab=Q2}
N 850 -140 860 -140 {lab=Q2}
N 850 -160 850 -140 {lab=Q2}
N 820 -160 850 -160 {lab=Q2}
N 800 -180 820 -180 {lab=Q2}
N 820 -180 820 -160 {lab=Q2}
N 790 -160 820 -160 {lab=Q2}
N 1210 -160 1310 -160 {lab=Q3}
N 1210 -200 1210 -160 {lab=Q3}
N 1200 -160 1210 -160 {lab=Q3}
N 1210 -280 1210 -260 {lab=VDD}
N 1210 -60 1210 -40 {lab=VSS}
N 1210 -140 1210 -120 {lab=Q3}
N 1200 -140 1210 -140 {lab=Q3}
N 1200 -160 1200 -140 {lab=Q3}
N 1170 -160 1200 -160 {lab=Q3}
N 1150 -180 1170 -180 {lab=Q3}
N 1170 -180 1170 -160 {lab=Q3}
N 1140 -160 1170 -160 {lab=Q3}
N 710 -1200 730 -1200 {lab=#net1}
N 710 -1250 710 -1200 {lab=#net1}
N 1190 -1250 1350 -1250 {lab=#net1}
N 1350 -1250 1350 -1200 {lab=#net1}
N 1350 -1200 1370 -1200 {lab=#net1}
N 1190 -1200 1210 -1200 {lab=#net1}
N 1190 -1250 1190 -1200 {lab=#net1}
N 1030 -1250 1190 -1250 {lab=#net1}
N 1030 -1200 1050 -1200 {lab=#net1}
N 1030 -1250 1030 -1200 {lab=#net1}
N 870 -1250 1030 -1250 {lab=#net1}
N 870 -1200 890 -1200 {lab=#net1}
N 870 -1250 870 -1200 {lab=#net1}
N 710 -1250 870 -1250 {lab=#net1}
N 1310 -1270 1410 -1270 {lab=VDD}
N 770 -1270 770 -1200 {lab=VDD}
N 930 -1270 930 -1200 {lab=VDD}
N 830 -1270 930 -1270 {lab=VDD}
N 1090 -1270 1090 -1200 {lab=VDD}
N 990 -1270 1090 -1270 {lab=VDD}
N 1250 -1270 1250 -1200 {lab=VDD}
N 1150 -1270 1250 -1270 {lab=VDD}
N 590 -1200 710 -1200 {lab=#net1}
N 590 -1210 590 -1200 {lab=#net1}
N 540 -1200 590 -1200 {lab=#net1}
N 540 -1200 540 -1160 {lab=#net1}
N 530 -1200 540 -1200 {lab=#net1}
N 490 -1160 540 -1160 {lab=#net1}
N 490 -1170 490 -1160 {lab=#net1}
N 710 -880 730 -880 {lab=#net2}
N 590 -880 590 -870 {lab=#net2}
N 540 -920 540 -880 {lab=#net2}
N 540 -880 590 -880 {lab=#net2}
N 490 -1270 490 -1200 {lab=VDD}
N 490 -1160 490 -1150 {lab=#net1}
N 530 -880 540 -880 {lab=#net2}
N 490 -920 490 -910 {lab=#net2}
N 490 -920 540 -920 {lab=#net2}
N 650 -810 770 -810 {lab=VSS}
N 1410 -880 1410 -810 {lab=VSS}
N 1250 -880 1250 -810 {lab=VSS}
N 1090 -880 1090 -810 {lab=VSS}
N 930 -880 930 -810 {lab=VSS}
N 770 -880 770 -810 {lab=VSS}
N 590 -1270 590 -1240 {lab=VDD}
N 490 -1270 590 -1270 {lab=VDD}
N 490 -880 490 -810 {lab=VSS}
N 590 -840 590 -810 {lab=VSS}
N 490 -810 590 -810 {lab=VSS}
N 710 -880 710 -830 {lab=#net2}
N 590 -880 710 -880 {lab=#net2}
N 1190 -830 1350 -830 {lab=#net2}
N 1350 -880 1350 -830 {lab=#net2}
N 1350 -880 1370 -880 {lab=#net2}
N 1190 -880 1210 -880 {lab=#net2}
N 1190 -880 1190 -830 {lab=#net2}
N 1030 -830 1190 -830 {lab=#net2}
N 1030 -880 1050 -880 {lab=#net2}
N 1030 -880 1030 -830 {lab=#net2}
N 870 -830 1030 -830 {lab=#net2}
N 870 -880 890 -880 {lab=#net2}
N 870 -880 870 -830 {lab=#net2}
N 710 -830 870 -830 {lab=#net2}
N 490 -940 490 -920 {lab=#net2}
N 1410 -1270 1410 -1200 {lab=VDD}
N 1350 -1250 1510 -1250 {lab=#net1}
N 1510 -1250 1510 -1200 {lab=#net1}
N 1510 -1200 1530 -1200 {lab=#net1}
N 1470 -1270 1570 -1270 {lab=VDD}
N 1570 -880 1570 -810 {lab=VSS}
N 1350 -830 1510 -830 {lab=#net2}
N 1510 -880 1510 -830 {lab=#net2}
N 1510 -880 1530 -880 {lab=#net2}
N 1570 -1270 1570 -1200 {lab=VDD}
N 1510 -1250 1670 -1250 {lab=#net1}
N 1670 -1250 1670 -1200 {lab=#net1}
N 1670 -1200 1690 -1200 {lab=#net1}
N 1630 -1270 1730 -1270 {lab=VDD}
N 1730 -880 1730 -810 {lab=VSS}
N 1510 -830 1670 -830 {lab=#net2}
N 1670 -880 1670 -830 {lab=#net2}
N 1670 -880 1690 -880 {lab=#net2}
N 1730 -1270 1730 -1200 {lab=VDD}
N 120 -1160 120 -1140 {lab=#net3}
N 120 -930 120 -910 {lab=#net4}
N 290 -970 450 -970 {lab=#net4}
N 120 -930 290 -930 {lab=#net4}
N 120 -950 120 -930 {lab=#net4}
N 290 -1120 450 -1120 {lab=#net3}
N 120 -1160 290 -1160 {lab=#net3}
N 120 -1180 120 -1160 {lab=#net3}
N 290 -970 290 -930 {lab=#net4}
N 290 -1160 290 -1120 {lab=#net3}
N 520 -1240 550 -1240 {lab=ENP}
N 1830 -1200 1850 -1200 {lab=#net1}
N 1790 -1270 1890 -1270 {lab=VDD}
N 1890 -880 1890 -810 {lab=VSS}
N 1830 -880 1850 -880 {lab=#net2}
N 1890 -1270 1890 -1200 {lab=VDD}
N 1830 -1250 1990 -1250 {lab=#net1}
N 1990 -1250 1990 -1200 {lab=#net1}
N 1990 -1200 2010 -1200 {lab=#net1}
N 1950 -1270 2050 -1270 {lab=VDD}
N 2050 -880 2050 -810 {lab=VSS}
N 1990 -880 1990 -830 {lab=#net2}
N 1990 -880 2010 -880 {lab=#net2}
N 2050 -1270 2050 -1200 {lab=VDD}
N 1830 -830 1990 -830 {lab=#net2}
N 1830 -880 1830 -830 {lab=#net2}
N 1670 -830 1830 -830 {lab=#net2}
N 1830 -1250 1830 -1200 {lab=#net1}
N 1670 -1250 1830 -1250 {lab=#net1}
N 120 -1030 120 -1010 {lab=VDD}
N 490 -1290 490 -1270 {lab=VDD}
N 120 -1080 120 -1060 {lab=VSS}
N 120 -850 120 -810 {lab=VSS}
N 270 -1290 490 -1290 {lab=VDD}
N 120 -1290 120 -1240 {lab=VDD}
N 120 -1030 270 -1030 {lab=VDD}
N 270 -1290 270 -1030 {lab=VDD}
N 120 -1290 270 -1290 {lab=VDD}
N 120 -1060 310 -1060 {lab=VSS}
N 310 -1060 310 -810 {lab=VSS}
N 310 -810 490 -810 {lab=VSS}
N 120 -810 310 -810 {lab=VSS}
N 1150 -810 1250 -810 {lab=VSS}
N 1310 -810 1410 -810 {lab=VSS}
N 1470 -810 1570 -810 {lab=VSS}
N 1630 -810 1730 -810 {lab=VSS}
N 1790 -810 1890 -810 {lab=VSS}
N 1950 -810 2050 -810 {lab=VSS}
N 830 -810 930 -810 {lab=VSS}
N 400 -840 550 -840 {lab=ENN}
N 2210 -1270 2210 -1190 {lab=VDD}
N 2110 -1270 2210 -1270 {lab=VDD}
N 520 -1290 520 -1240 {lab=ENP}
N 400 -1240 520 -1240 {lab=ENP}
N 520 -1290 2150 -1290 {lab=ENP}
N 2150 -1290 2150 -1190 {lab=ENP}
N 2150 -1190 2170 -1190 {lab=ENP}
N 680 -960 2150 -960 {lab=RO_RAW}
N 2150 -1040 2150 -960 {lab=RO_RAW}
N 310 -1060 490 -1060 {lab=VSS}
N 270 -1030 490 -1030 {lab=VDD}
N 490 -1030 490 -1000 {lab=VDD}
N 490 -1090 490 -1060 {lab=VSS}
N 650 -1270 650 -1120 {lab=VDD}
N 490 -970 650 -970 {lab=VSS}
N 650 -970 650 -810 {lab=VSS}
N 590 -810 650 -810 {lab=VSS}
N 590 -1270 650 -1270 {lab=VDD}
N 490 -1120 650 -1120 {lab=VDD}
N 770 -1040 770 -1030 {lab=#net5}
N 730 -1040 730 -1000 {lab=RO_RAW}
N 930 -1040 930 -1030 {lab=#net6}
N 890 -1040 890 -1000 {lab=#net5}
N 770 -1040 890 -1040 {lab=#net5}
N 770 -1050 770 -1040 {lab=#net5}
N 890 -1080 890 -1040 {lab=#net5}
N 1090 -1040 1090 -1030 {lab=#net7}
N 1050 -1040 1050 -1000 {lab=#net6}
N 1090 -1040 1210 -1040 {lab=#net7}
N 1090 -1050 1090 -1040 {lab=#net7}
N 1250 -1040 1250 -1030 {lab=#net8}
N 1210 -1040 1210 -1000 {lab=#net7}
N 1250 -1040 1370 -1040 {lab=#net8}
N 1250 -1050 1250 -1040 {lab=#net8}
N 1210 -1080 1210 -1040 {lab=#net7}
N 1410 -1040 1410 -1030 {lab=#net9}
N 1370 -1040 1370 -1000 {lab=#net8}
N 1410 -1040 1530 -1040 {lab=#net9}
N 1410 -1050 1410 -1040 {lab=#net9}
N 1570 -1040 1570 -1030 {lab=#net10}
N 1530 -1040 1530 -1000 {lab=#net9}
N 1570 -1040 1690 -1040 {lab=#net10}
N 1570 -1050 1570 -1040 {lab=#net10}
N 1530 -1080 1530 -1040 {lab=#net9}
N 1370 -1080 1370 -1040 {lab=#net8}
N 1730 -1040 1730 -1030 {lab=#net11}
N 1690 -1040 1690 -1000 {lab=#net10}
N 1730 -1040 1850 -1040 {lab=#net11}
N 1730 -1050 1730 -1040 {lab=#net11}
N 1890 -1040 1890 -1030 {lab=#net12}
N 1850 -1040 1850 -1000 {lab=#net11}
N 1890 -1040 2010 -1040 {lab=#net12}
N 1890 -1050 1890 -1040 {lab=#net12}
N 1850 -1080 1850 -1040 {lab=#net11}
N 1690 -1080 1690 -1040 {lab=#net10}
N 2050 -1040 2050 -1030 {lab=RO_RAW}
N 2010 -1040 2010 -1000 {lab=#net12}
N 2150 -1040 2210 -1040 {lab=RO_RAW}
N 2050 -1050 2050 -1040 {lab=RO_RAW}
N 2010 -1080 2010 -1040 {lab=#net12}
N 2050 -1040 2150 -1040 {lab=RO_RAW}
N 770 -1170 770 -1110 {lab=#net13}
N 930 -1170 930 -1110 {lab=#net14}
N 1090 -1170 1090 -1110 {lab=#net15}
N 1250 -1170 1250 -1110 {lab=#net16}
N 1410 -1170 1410 -1110 {lab=#net17}
N 1570 -1170 1570 -1110 {lab=#net18}
N 1730 -1170 1730 -1110 {lab=#net19}
N 1890 -1170 1890 -1110 {lab=#net20}
N 2050 -1170 2050 -1110 {lab=#net21}
N 770 -970 770 -910 {lab=#net22}
N 930 -970 930 -910 {lab=#net23}
N 1090 -970 1090 -910 {lab=#net24}
N 1250 -970 1250 -910 {lab=#net25}
N 1410 -970 1410 -910 {lab=#net26}
N 1570 -970 1570 -910 {lab=#net27}
N 1730 -970 1730 -910 {lab=#net28}
N 1890 -970 1890 -910 {lab=#net29}
N 2050 -970 2050 -910 {lab=#net30}
N 770 -1000 830 -1000 {lab=VSS}
N 830 -1000 830 -810 {lab=VSS}
N 770 -810 830 -810 {lab=VSS}
N 930 -1000 990 -1000 {lab=VSS}
N 990 -1000 990 -810 {lab=VSS}
N 930 -810 990 -810 {lab=VSS}
N 1090 -1000 1150 -1000 {lab=VSS}
N 1150 -1000 1150 -810 {lab=VSS}
N 1250 -1000 1310 -1000 {lab=VSS}
N 1310 -1000 1310 -810 {lab=VSS}
N 1090 -810 1150 -810 {lab=VSS}
N 1250 -810 1310 -810 {lab=VSS}
N 1410 -1000 1470 -1000 {lab=VSS}
N 1470 -1000 1470 -810 {lab=VSS}
N 1570 -1000 1630 -1000 {lab=VSS}
N 1630 -1000 1630 -810 {lab=VSS}
N 1410 -810 1470 -810 {lab=VSS}
N 1570 -810 1630 -810 {lab=VSS}
N 1730 -1000 1790 -1000 {lab=VSS}
N 1790 -1000 1790 -810 {lab=VSS}
N 1890 -1000 1950 -1000 {lab=VSS}
N 1950 -1000 1950 -810 {lab=VSS}
N 1730 -810 1790 -810 {lab=VSS}
N 1890 -810 1950 -810 {lab=VSS}
N 2050 -1000 2110 -1000 {lab=VSS}
N 2110 -1000 2110 -810 {lab=VSS}
N 2050 -810 2110 -810 {lab=VSS}
N 990 -810 1090 -810 {lab=VSS}
N 770 -1080 830 -1080 {lab=VDD}
N 830 -1270 830 -1080 {lab=VDD}
N 770 -1270 830 -1270 {lab=VDD}
N 650 -1270 770 -1270 {lab=VDD}
N 930 -1080 990 -1080 {lab=VDD}
N 990 -1270 990 -1080 {lab=VDD}
N 930 -1270 990 -1270 {lab=VDD}
N 1090 -1080 1150 -1080 {lab=VDD}
N 1150 -1270 1150 -1080 {lab=VDD}
N 1250 -1080 1310 -1080 {lab=VDD}
N 1310 -1270 1310 -1080 {lab=VDD}
N 1090 -1270 1150 -1270 {lab=VDD}
N 1250 -1270 1310 -1270 {lab=VDD}
N 1410 -1080 1470 -1080 {lab=VDD}
N 1470 -1270 1470 -1080 {lab=VDD}
N 1570 -1080 1630 -1080 {lab=VDD}
N 1630 -1270 1630 -1080 {lab=VDD}
N 1410 -1270 1470 -1270 {lab=VDD}
N 1570 -1270 1630 -1270 {lab=VDD}
N 1730 -1080 1790 -1080 {lab=VDD}
N 1790 -1270 1790 -1080 {lab=VDD}
N 1890 -1080 1950 -1080 {lab=VDD}
N 1950 -1270 1950 -1080 {lab=VDD}
N 1730 -1270 1790 -1270 {lab=VDD}
N 1890 -1270 1950 -1270 {lab=VDD}
N 2050 -1080 2110 -1080 {lab=VDD}
N 2110 -1270 2110 -1080 {lab=VDD}
N 2050 -1270 2110 -1270 {lab=VDD}
N 2210 -1160 2210 -1040 {lab=RO_RAW}
N 680 -1040 680 -960 {lab=RO_RAW}
N 680 -1040 730 -1040 {lab=RO_RAW}
N 730 -1080 730 -1040 {lab=RO_RAW}
N 930 -1040 1050 -1040 {lab=#net6}
N 930 -1050 930 -1040 {lab=#net6}
N 1050 -1080 1050 -1040 {lab=#net6}
N 2650 -1040 2650 -1020 {lab=#net31}
N 2790 -1040 2790 -990 {lab=#net31}
N 2970 -1040 2970 -990 {lab=#net32}
N 3010 -1040 3010 -1020 {lab=RO_BUF}
N 2610 -1040 2610 -990 {lab=RO_RAW}
N 2830 -1040 2830 -1020 {lab=#net32}
N 2830 -1040 2970 -1040 {lab=#net32}
N 2830 -1060 2830 -1040 {lab=#net32}
N 2970 -1090 2970 -1040 {lab=#net32}
N 2650 -1040 2790 -1040 {lab=#net31}
N 2650 -1060 2650 -1040 {lab=#net31}
N 2790 -1090 2790 -1040 {lab=#net31}
N 3010 -1060 3010 -1040 {lab=RO_BUF}
N 2610 -1090 2610 -1040 {lab=RO_RAW}
N 2650 -1140 2830 -1140 {lab=VDD}
N 2830 -940 2830 -810 {lab=VSS}
N 2650 -940 2830 -940 {lab=VSS}
N 2830 -1140 3010 -1140 {lab=VDD}
N 2830 -1140 2830 -1090 {lab=VDD}
N 3010 -1140 3010 -1090 {lab=VDD}
N 2650 -1140 2650 -1090 {lab=VDD}
N 2830 -940 3010 -940 {lab=VSS}
N 2650 -990 2650 -940 {lab=VSS}
N 2830 -990 2830 -940 {lab=VSS}
N 3010 -990 3010 -940 {lab=VSS}
N 2210 -1040 2610 -1040 {lab=RO_RAW}
N 3010 -1040 3230 -1040 {lab=RO_BUF}
N 2830 -1270 3210 -1270 {lab=VDD}
N 3210 -1270 3210 -1060 {lab=VDD}
N 3210 -1060 3230 -1060 {lab=VDD}
N 3210 -1000 3230 -1000 {lab=VSS}
N 3210 -1000 3210 -810 {lab=VSS}
N 2830 -810 3210 -810 {lab=VSS}
N 2110 -810 2830 -810 {lab=VSS}
N 2830 -1270 2830 -1140 {lab=VDD}
N 2210 -1270 2830 -1270 {lab=VDD}
C {TSENSE8490-main/schematic/xschem/digital/div16/xschem/div16.sym} 3330 -1000 0 0 {name=x3}
C {lab_pin.sym} 100 -490 0 0 {name=p13 sig_type=std_logic lab=ENP
}
C {lab_pin.sym} 440 -490 0 0 {name=p14 sig_type=std_logic lab=ENN
}
C {lab_pin.sym} 3230 -1020 0 0 {name=p11 sig_type=std_logic lab=ENN
}
C {sg13cmos5l_pr/bondpad.sym} 190 -1330 0 0 {name=X4
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {sg13cmos5l_pr/bondpad.sym} 220 -770 2 0 {name=X5
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {sg13cmos5l_pr/bondpad.sym} 270 -530 0 0 {name=X6
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {sg13cmos5l_pr/bondpad.sym} 610 -530 0 0 {name=X7
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {sg13cmos5l_pr/bondpad.sym} 960 -530 0 0 {name=X8
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {sg13cmos5l_pr/bondpad.sym} 1310 -530 0 0 {name=X9
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {sg13cmos5l_pr/bondpad.sym} 270 -200 0 0 {name=X10
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {sg13cmos5l_pr/bondpad.sym} 610 -200 0 0 {name=X11
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {sg13cmos5l_pr/bondpad.sym} 960 -200 0 0 {name=X12
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {sg13cmos5l_pr/bondpad.sym} 1310 -200 0 0 {name=X13
model=bondpad
spiceprefix=X
size=150u
shape=0
padtype=0
}
C {lab_pin.sym} 3440 -1060 2 0 {name=p3 sig_type=std_logic lab=Q0
}
C {lab_pin.sym} 3520 -1040 2 0 {name=p4 sig_type=std_logic lab=Q1}
C {lab_pin.sym} 3520 -1020 2 0 {name=p5 sig_type=std_logic lab=Q2}
C {lab_pin.sym} 3440 -1000 2 0 {name=p7 sig_type=std_logic lab=Q3}
C {iopin.sym} 110 -510 2 0 {name=p22 lab=ENP}
C {iopin.sym} 450 -510 2 0 {name=p23 lab=ENN}
C {lab_pin.sym} 790 -490 0 0 {name=p24 sig_type=std_logic lab=RO_RAW
}
C {iopin.sym} 800 -510 2 0 {name=p25 lab=RO_RAW}
C {iopin.sym} 1150 -510 2 0 {name=p30 lab=RO_BUF}
C {lab_pin.sym} 1140 -490 0 0 {name=p36 sig_type=std_logic lab=RO_BUF
}
C {sg13cmos5l_pr/diodevdd_4kv.sym} 170 -560 0 0 {name=D1
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13cmos5l_pr/diodevss_4kv.sym} 170 -420 0 0 {name=D2
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13cmos5l_pr/diodevdd_4kv.sym} 510 -560 0 0 {name=D3
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13cmos5l_pr/diodevss_4kv.sym} 510 -420 0 0 {name=D4
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13cmos5l_pr/diodevdd_4kv.sym} 860 -560 0 0 {name=D5
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13cmos5l_pr/diodevss_4kv.sym} 860 -420 0 0 {name=D6
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13cmos5l_pr/diodevdd_4kv.sym} 1210 -560 0 0 {name=D7
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13cmos5l_pr/diodevss_4kv.sym} 1210 -420 0 0 {name=D8
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13cmos5l_pr/diodevdd_4kv.sym} 170 -230 0 0 {name=D9
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13cmos5l_pr/diodevss_4kv.sym} 170 -90 0 0 {name=D10
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13cmos5l_pr/diodevdd_4kv.sym} 510 -230 0 0 {name=D11
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13cmos5l_pr/diodevss_4kv.sym} 510 -90 0 0 {name=D12
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13cmos5l_pr/diodevdd_4kv.sym} 860 -230 0 0 {name=D13
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13cmos5l_pr/diodevss_4kv.sym} 860 -90 0 0 {name=D14
model=diodevss_4kv
spiceprefix=X
m=1
}
C {sg13cmos5l_pr/diodevdd_4kv.sym} 1210 -230 0 0 {name=D15
model=diodevdd_4kv
m=1
spiceprefix=X
}
C {sg13cmos5l_pr/diodevss_4kv.sym} 1210 -90 0 0 {name=D16
model=diodevss_4kv
spiceprefix=X
m=1
}
C {lab_pin.sym} 170 -610 0 0 {name=p6 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 510 -610 0 0 {name=p12 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 860 -610 0 0 {name=p18 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 1210 -610 0 0 {name=p34 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 1180 -420 0 0 {name=p38 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 830 -420 0 0 {name=p40 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 480 -420 0 0 {name=p42 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 140 -420 0 0 {name=p44 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 170 -280 0 0 {name=p46 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 510 -280 0 0 {name=p48 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 860 -280 0 0 {name=p50 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 1210 -280 0 0 {name=p51 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 1180 -90 0 0 {name=p52 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 830 -90 0 0 {name=p54 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 480 -90 0 0 {name=p56 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 140 -90 0 0 {name=p57 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 140 -560 0 0 {name=p10 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 170 -370 0 0 {name=p15 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 140 -230 0 0 {name=p21 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 170 -40 0 0 {name=p37 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 510 -40 0 0 {name=p39 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 480 -230 0 0 {name=p41 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 830 -230 0 0 {name=p43 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 860 -40 0 0 {name=p45 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 1210 -40 0 0 {name=p47 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 1180 -230 0 0 {name=p49 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 1210 -370 0 0 {name=p53 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 1180 -560 0 0 {name=p55 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 830 -560 0 0 {name=p58 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 860 -370 0 0 {name=p59 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 480 -560 0 0 {name=p60 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 510 -370 0 0 {name=p61 sig_type=std_logic lab=VSS
}
C {iopin.sym} 110 -180 2 0 {name=p26 lab=Q0}
C {iopin.sym} 450 -180 2 0 {name=p27 lab=Q1}
C {iopin.sym} 800 -180 2 0 {name=p28 lab=Q2}
C {iopin.sym} 1150 -180 2 0 {name=p29 lab=Q3}
C {lab_pin.sym} 100 -160 0 0 {name=p31 sig_type=std_logic lab=Q0
}
C {lab_pin.sym} 440 -160 0 0 {name=p32 sig_type=std_logic lab=Q1}
C {lab_pin.sym} 790 -160 0 0 {name=p33 sig_type=std_logic lab=Q2}
C {lab_pin.sym} 1140 -160 0 0 {name=p35 sig_type=std_logic lab=Q3}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 750 -1200 0 0 {name=M1
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 570 -1240 0 0 {name=M21
l=0.13u
w=10u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 570 -840 0 0 {name=M22
l=0.13u
w=10u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 510 -1200 0 1 {name=M23
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 510 -880 0 1 {name=M24
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 750 -880 0 0 {name=M4
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 910 -1200 0 0 {name=M5
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 910 -880 0 0 {name=M8
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 1070 -1200 0 0 {name=M9
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 1070 -880 0 0 {name=M12
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 1230 -1200 0 0 {name=M13
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 1230 -880 0 0 {name=M16
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 1390 -1200 0 0 {name=M17
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 1390 -880 0 0 {name=M20
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 1550 -1200 0 0 {name=M25
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 1550 -880 0 0 {name=M28
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 1710 -1200 0 0 {name=M29
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 1710 -880 0 0 {name=M32
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 470 -1120 0 0 {name=M2
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 470 -970 0 0 {name=M3
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/rsil.sym} 120 -1210 0 0 {name=R6
w=0.5e-6
l=75e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
value="expr_eng(  ( 9.0e-6 / @w + 7.0 * ( (@b + 1)* @l + ( 1.081*( @w + 1.0e-8 ) + 0.18e-6 )*@b ) / ( @w + 1.0e-8 ) ) / @m  )"
}
C {sg13cmos5l_pr/rsil.sym} 120 -1110 0 0 {name=R7
w=0.5e-6
l=10e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
value="expr_eng(  ( 9.0e-6 / @w + 7.0 * ( (@b + 1)* @l + ( 1.081*( @w + 1.0e-8 ) + 0.18e-6 )*@b ) / ( @w + 1.0e-8 ) ) / @m  )"
}
C {sg13cmos5l_pr/rsil.sym} 120 -880 0 0 {name=R1
w=0.5e-6
l=75e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
value="expr_eng(  ( 9.0e-6 / @w + 7.0 * ( (@b + 1)* @l + ( 1.081*( @w + 1.0e-8 ) + 0.18e-6 )*@b ) / ( @w + 1.0e-8 ) ) / @m  )"
}
C {sg13cmos5l_pr/rsil.sym} 120 -980 0 0 {name=R2
w=0.5e-6
l=10e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
value="expr_eng(  ( 9.0e-6 / @w + 7.0 * ( (@b + 1)* @l + ( 1.081*( @w + 1.0e-8 ) + 0.18e-6 )*@b ) / ( @w + 1.0e-8 ) ) / @m  )"
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 1870 -1200 0 0 {name=M6
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 1870 -880 0 0 {name=M7
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 2030 -1200 0 0 {name=M10
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_nmos.sym} 2030 -880 0 0 {name=M11
l=0.46u
w=1.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13cmos5l_pr/sg13_lv_pmos.sym} 2190 -1190 0 0 {name=M14
l=0.13u
w=0.3u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 750 -1000 0 0 {name=M15
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 750 -1080 2 1 {name=M18
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 910 -1000 0 0 {name=M19
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 910 -1080 2 1 {name=M26
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1070 -1000 0 0 {name=M27
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1070 -1080 2 1 {name=M30
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1230 -1000 0 0 {name=M31
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1230 -1080 2 1 {name=M33
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1390 -1000 0 0 {name=M34
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1390 -1080 2 1 {name=M35
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1550 -1000 0 0 {name=M36
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1550 -1080 2 1 {name=M37
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -1000 0 0 {name=M38
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1710 -1080 2 1 {name=M39
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1870 -1000 0 0 {name=M40
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1870 -1080 2 1 {name=M41
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2030 -1000 0 0 {name=M42
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2030 -1080 2 1 {name=M43
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2630 -990 0 0 {name=M44
l=0.45u
w=2.0u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2630 -1090 2 1 {name=M45
l=0.45u
w=1.0u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2810 -990 0 0 {name=M46
l=0.45u
w=3.99u
ng=3
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2810 -1090 2 1 {name=M47
l=0.45u
w=2.0u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2990 -990 0 0 {name=M48
l=0.45u
w=16.0u
ng=5
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2990 -1090 2 1 {name=M49
l=0.45u
w=7.995u
ng=3
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 2650 -1140 0 0 {name=p72 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2650 -940 0 0 {name=p73 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2400 -1040 1 0 {name=p1 sig_type=std_logic lab=RO_RAW
}
C {lab_pin.sym} 3140 -1040 1 0 {name=p2 sig_type=std_logic lab=RO_BUF
}
C {lab_pin.sym} 120 -1290 0 0 {name=p8 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 120 -810 0 0 {name=p9 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 400 -1240 0 0 {name=p16 sig_type=std_logic lab=ENP
}
C {lab_pin.sym} 400 -840 0 0 {name=p17 sig_type=std_logic lab=ENN
}
C {sg13cmos5l_pr/ptap1.sym} -250 -710 0 0 {name=R3
model=ptap1
spiceprefix=X
w=0.78e-6
l=0.78e-6
}
C {sg13cmos5l_pr/sub.sym} -250 -680 0 0 {name=l1 lab=sub!}
C {lab_pin.sym} -250 -740 0 0 {name=p20 sig_type=std_logic lab=VSS
}
